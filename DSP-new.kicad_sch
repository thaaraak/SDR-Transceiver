File: DSP-new.kicad_sch (KiCad schematic)
At the start: 24 parts, among them J10 USB to Serial, J11 LCD, Q4 2N3904-SMD, Q5 2N3904-SMD, Q6 AO3400A, SW1 RST, SW2 Frequency, SW3 Menu, SW4 BOOT, U6 ESP32-A1S

Commit message: gg
Parts:
- removed C50, C51: 1uF, Capacitor_SMD:C_1206_3216Metric, symbol Xenir:Capacitor
- removed J10: USB to Serial, Connector_PinSocket_2.54mm:PinSocket_1x07_P2.54mm_Vertical, symbol Connector:Conn_01x07_Female
- removed Q4, Q5: 2N3904-SMD, Package_TO_SOT_SMD:SOT-23, symbol Tayloe-Mixer-v3-rescue:2N3904-SMD-xenir
- removed R44, R45: 10k, Resistor_SMD:R_0805_2012Metric, symbol Tayloe-Mixer-v3-rescue:Resistor-Xenir-esp32-a1s-rescue
- removed SW1: RST, Button_Switch_SMD:SW_SPST_B3U-1000P, symbol Switch:SW_DIP_x01
- removed SW4: BOOT, Button_Switch_SMD:SW_SPST_B3U-1000P, symbol Switch:SW_DIP_x01
- added U?: PCBARTISTS-ES8388, symbol xenir:PCBARTISTS-ES8388
Connections:
- net DSP-OUTL: now also C26.2, R22.1
Other:
- moved on the sheet: C24, C25, C26, C27, C28, C29, J11, R21, R22, SW2, SW3, U6

Commit message: added esp32-s3
Parts:
- removed C24, C26: 22uF, Capacitor_SMD:CP_Elec_4x4.5, symbol Device:C_Polarized
- removed C25, C27: 1uF, Capacitor_SMD:C_1206_3216Metric, symbol Xenir:Capacitor
- removed C28, C29: .1uF, Capacitor_SMD:C_1206_3216Metric, symbol Xenir:Capacitor
- removed R21, R22: 330, Resistor_SMD:R_0805_2012Metric, symbol Xenir:Resistor
- removed U6: ESP32-A1S, xenir_v6:esp32-a1s-header, symbol Xenir:ESP32-A1S
- added C? (x2): .1uF, Capacitor_SMD:C_1206_3216Metric, symbol Xenir:Capacitor
- added C? (x2): 1uF, Capacitor_SMD:C_1206_3216Metric, symbol Xenir:Capacitor
- added C? (x2): 22uF, Capacitor_SMD:CP_Elec_4x4.5, symbol Device:C_Polarized
- added R? (x2): 330, Resistor_SMD:R_0805_2012Metric, symbol Xenir:Resistor
- added U?: ESP32-S3, symbol xenir_v6:ESP32-S3
Connections:
- net +3V3: now also U?.1 (3V3), U?.2 (3V3)
- net +5V: now also U?.21 (5V)
- net DSP-INL: now also C?.2
- net DSP-INR: now also C?.2
- net DSP-OUTL: now also C?.2, C?.2, R?.1, R?.2
- net DSP-OUTR: now also C?.2, R?.2
- net GND: now also U?.4 (GND), C?.1, C?.1, U?.22 (GND), U?.23 (GND), U?.24 (GND), U?.44 (GND)
- net GPIO12: now also U?.18 (GPIO12)
- net GPIO13: now also U?.19 (GPIO13)
- net GPIO14: now also U?.20 (GPIO14)
- net GPIO15: now also U?.8 (GPIO15)
- net GPIO4: now also U?.4 (GPIO4)
- net PTT-IN: now also U?.12 (GPIO8)
- net SCL: now also U?.28 (SCL), U?.10 (GPIO17)
- net SDA: now also U?.27 (SDA), U?.11 (GPIO18)
- net MCLK: now reaches U?.1 (MCLK)
- net MCLK: now also U?.31 (GPIO0)
- net at U?.14 (ROUT2): now also C?.1
- net at U?.15 (LOUT2): now also C?.1
- net at U?.23 (RIN1): now also C?.1
- net at U?.24 (LIN1): now also C?.1
- net SCLK: now reaches U?.5 (SCLK)
- net SCLK: now also U?.26 (GPIO20)
- net ESP-DOUT: now reaches U?.6 (DSDIN)
- net ESP-DOUT: now also U?.28 (GPIO47)
- net LRCLK: now reaches U?.7 (LRCLK)
- net LRCLK: now also U?.27 (GPIO21)
- net ESP-DIN: now reaches U?.8 (ASDOUT)
- net ESP-DIN: now also U?.25 (GPIO19)
- net GPIO2 renamed GPIO7
- net GPIO7: now also U?.7 (GPIO7)
- net GPIO21 renamed GPIO10
- net GPIO10: now also U?.16 (GPIO10)
- new net: C?.2, R?.1
Other:
- moved on the sheet: J11, Q6, R46, R47, SW2, SW3, U?

Commit message: dd
Parts:
- U12: renamed from U?; footprint (none) -> xenir:PCBArtist-ES8388
- U6: renamed from U?; footprint (none) -> xenir_v6:ESP32-S3
- gave numbers to parts that had none: 8
Connections:
- net +3V3: now also U12.17 (AVDD), U12.2 (DVDD)
- net DSP-OUTL: no longer C27.2, R22.1
- net ESP-DOUT: now also U6.27 (GPIO21); no longer U6.28 (GPIO47)
- net LRCLK: now also U6.26 (GPIO20); no longer U6.27 (GPIO21)
- net SCLK: now also U6.28 (GPIO47); no longer U6.26 (GPIO20)
- new net: C27.2, R22.1
Changed lines of the file:
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@@
 (kicad_sch (version 20211123) (generator eeschema)
   (paper "A4")
-  (junction (at 215.9 55.88) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 226.06 55.88) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 215.9 55.88) (xy 215.9 58.42))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
-  (wire (pts (xy 215.9 49.53) (xy 215.9 55.88))
+  (wire (pts (xy 215.9 49.53) (xy 215.9 58.42))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     )
   )
-  (global_label "SCLK" (shape input) (at 102.87 82.55 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left))
-    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 110.0607 82.4706 0)
-      (effects (font (size 1.27 1.27)) (justify left) hide)
-    )
-  )
-  (global_label "ESP-DOUT" (shape input) (at 102.87 77.47 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left))
-    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 115.3826 77.3906 0)
+  (global_label "SCLK" (shape input) (at 102.87 77.47 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left))
+    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 110.0607 77.3906 0)
+      (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+  )
+  (global_label "ESP-DOUT" (shape input) (at 102.87 80.01 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left))
+    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 115.3826 79.9306 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
@@
     )
   )
-  (global_label "LRCLK" (shape input) (at 102.87 80.01 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left))
-    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 111.1493 79.9306 0)
+  (global_label "LRCLK" (shape input) (at 102.87 82.55 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left))
+    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 111.1493 82.4706 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
@@
   (symbol (lib_id "Xenir:Capacitor") (at 226.06 59.69 90) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "C?" (id 0) (at 228.6 58.42 90)
+    (property "Reference" "C29" (id 0) (at 228.6 58.42 90)
       (effects (font (size 0.7112 0.7112)) (justify right))
     )
@@
   (symbol (lib_id "power:GND") (at 62.23 92.71 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR?" (id 0) (at 62.23 99.06 0)
+    (property "Reference" "#PWR0200" (id 0) (at 62.23 99.06 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "1")
   )
+  (symbol (lib_id "power:+3V3") (at 161.29 41.91 0) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "#PWR?" (id 0) (at 161.29 45.72 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+3V3" (id 1) (at 160.02 38.1 0))
+    (property "Footprint" "" (id 2) (at 161.29 41.91 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 161.29 41.91 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
   (symbol (lib_id "Xenir:Capacitor") (at 195.58 72.39 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "C?" (id 0) (at 193.04 71.12 0)
+    (property "Reference" "C26" (id 0) (at 193.04 71.12 0)
       (effects (font (size 0.7112 0.7112)))
     )
@@
   (symbol (lib_id "Xenir:Resistor") (at 220.98 55.88 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "R?" (id 0) (at 218.44 53.34 0)
+    (property "Reference" "R22" (id 0) (at 218.44 53.34 0)
       (effects (font (size 0.7112 0.7112)))
     )
@@
   (symbol (lib_id "power:GND") (at 215.9 66.04 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR?" (id 0) (at 215.9 72.39 0)
+    (property "Reference" "#PWR0192" (id 0) (at 215.9 72.39 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Device:C_Polarized") (at 200.66 55.88 90) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "C?" (id 0) (at 198.12 52.07 90))
+    (property "Reference" "C27" (id 0) (at 198.12 52.07 90))
     (property "Value" "22uF" (id 1) (at 203.2 52.07 90))
     (property "Footprint" "Capacitor_SMD:CP_Elec_4x4.5" (id 2) (at 204.47 54.9148 0)
@@
   (symbol (lib_id "Xenir:Capacitor") (at 184.15 74.93 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "C?" (id 0) (at 181.61 73.66 0)
+    (property "Reference" "C24" (id 0) (at 181.61 73.66 0)
       (effects (font (size 0.7112 0.7112)))
     )
@@
   (symbol (lib_id "Device:C_Polarized") (at 190.5 58.42 90) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "C?" (id 0) (at 186.69 62.23 90))
+    (property "Reference" "C25" (id 0) (at 186.69 62.23 90))
     (property "Value" "22uF" (id 1) (at 191.77 62.23 90))
     (property "Footprint" "Capacitor_SMD:CP_Elec_4x4.5" (id 2) (at 194.31 57.4548 0)
@@
   (symbol (lib_id "xenir_v6:ESP32-S3") (at 82.55 29.21 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U?" (id 0) (at 82.55 29.21 0))
+    (property "Reference" "U6" (id 0) (at 82.55 29.21 0))
     (property "Value" "ESP32-S3" (id 1) (at 82.55 31.75 0))
-    (property "Footprint" "" (id 2) (at 82.55 29.21 0)
+    (property "Footprint" "xenir_v6:ESP32-S3" (id 2) (at 82.55 29.21 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Xenir:Capacitor") (at 215.9 62.23 90) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "C?" (id 0) (at 218.44 60.96 90)
+    (property "Reference" "C28" (id 0) (at 218.44 60.96 90)
       (effects (font (size 0.7112 0.7112)) (justify right))
     )
@@
   (symbol (lib_id "power:GND") (at 148.59 92.71 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR?" (id 0) (at 148.59 99.06 0)
+    (property "Reference" "#PWR0138" (id 0) (at 148.59 99.06 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "power:+3V3") (at 59.69 36.83 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR?" (id 0) (at 59.69 40.64 0)
+    (property "Reference" "#PWR0195" (id 0) (at 59.69 40.64 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "1")
   )
+  (symbol (lib_id "power:+3V3") (at 151.13 41.91 0) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "#PWR?" (id 0) (at 151.13 45.72 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+3V3" (id 1) (at 149.86 38.1 0))
+    (property "Footprint" "" (id 2) (at 151.13 41.91 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 151.13 41.91 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
   (symbol (lib_id "power:+5V") (at 62.23 90.17 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR?" (id 0) (at 62.23 93.98 0)
+    (property "Reference" "#PWR0201" (id 0) (at 62.23 93.98 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "power:GND") (at 111.76 36.83 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR?" (id 0) (at 111.76 43.18 0)
+    (property "Reference" "#PWR0199" (id 0) (at 111.76 43.18 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "xenir:PCBARTISTS-ES8388") (at 153.67 67.31 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U?" (id 0) (at 150.6094 92.71 0)
+    (property "Reference" "U12" (id 0) (at 150.6094 92.71 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (id 2) (at 152.4 68.58 0)
+    (property "Footprint" "xenir:PCBArtist-ES8388" (id 2) (at 152.4 68.58 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "power:GND") (at 226.06 63.5 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR?" (id 0) (at 226.06 69.85 0)
+    (property "Reference" "#PWR0139" (id 0) (at 226.06 69.85 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "power:GND") (at 102.87 92.71 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR?" (id 0) (at 102.87 99.06 0)
+    (property "Reference" "#PWR0202" (id 0) (at 102.87 99.06 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Xenir:Resistor") (at 210.82 58.42 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "R?" (id 0) (at 208.28 60.96 0)
+    (property "Reference" "R21" (id 0) (at 208.28 60.96 0)
       (effects (font (size 0.7112 0.7112)))
     )

Commit message: moved mclk to 45
Connections:
- net MCLK: now also U6.30 (GPIO45); no longer U6.31 (GPIO0)
Changed lines of the file:
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@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (global_label "MCLK" (shape input) (at 102.87 69.85 0) (fields_autoplaced)
+  (global_label "MCLK" (shape input) (at 102.87 72.39 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
-    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 110.3026 69.7706 0)
+    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 110.3026 72.3106 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
